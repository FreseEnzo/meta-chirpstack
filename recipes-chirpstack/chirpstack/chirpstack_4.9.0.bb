require chirpstack.inc

PV = "4.9.0"
CHIRPSTACK_VERSION = "4.9.0"
CHIRPSTACK_GW_BRIDGE_VERSION = "4.0.9"

CHIRPSTACK_SERVER_SHA256 = "1d07a1701290b103e58eb570d19cbdf39e0009a630c4b0364002e406fbb22423"
CHIRPSTACK_GW_BRIDGE_SHA256 = "2bb41ba0b9c451cf84473b7ca489b2ec62912fd8974544cb96667bae571b8815"
